DBUS_STUB = "com.victronenergy.vebus"
RUN_AS = "venus"
inherit nonroot
