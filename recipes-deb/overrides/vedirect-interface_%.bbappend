DBUS_STUB = "com.victronenergy.vedirect"
RUN_AS = "venus"
inherit nonroot
